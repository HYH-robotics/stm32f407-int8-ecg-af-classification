# Keil uVision project firmware.uvprojx, settings and files
target CMSISNN31_SINGLE_O2 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: cmsisnn31_single_o2
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F407xx,HSE_VALUE=8000000,ARM_MATH_DSP,CMSIS_NN_USE_SINGLE_ROUNDING
  c include: ..\common;..\dependencies\STM32F4xx_DFP\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\dependencies\CMSIS_5_5.9.0\CMSIS\Core\Include;..\dependencies\CMSIS_5_5.9.0\CMSIS\NN\Include;..\dependencies\CMSIS_5_5.9.0\CMSIS\DSP\Include;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group P6 firmware
    ../common/: startup_p6_f407.s
    ./: main.c
    ../dependencies/CMSIS_5_5.9.0/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1_x_n_s8.c arm_convolve_s8.c arm_nn_mat_mult_kernel_s8_s16.c
    ../dependencies/CMSIS_5_5.9.0/CMSIS/NN/Source/NNSupportFunctions/: arm_q7_to_q15_with_offset.c
